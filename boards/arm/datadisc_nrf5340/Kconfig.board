## temp/Kconfig.datadisc
```kconfig
#
# Copyright (c) 2021 Griffin Adams
#
# SPDX-License-Identifier: LicenseRef-Nordic-5-Clause
#

menu “DataDisc”

rsource “src/Kconfig”

endmenu
```
